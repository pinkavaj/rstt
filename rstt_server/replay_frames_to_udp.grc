<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>replay_frames_to_udp</value></param>
<param><key>description</key><value>Read frames from file and sent them to UDP socket</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_name_</value></param>
<param><key>value</key><value>file_name</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>file_name_</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>240</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>samples_per_second</key><value>rate</value></param>
<param><key>vlen</key><value>240</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_name</value></param>
<param><key>label</key><value>FileName</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>rate</value></param>
<param><key>value</key><value>100</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>r</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udp_host</value></param>
<param><key>label</key><value>dest-host</value></param>
<param><key>value</key><value>localhost</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>d</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udp_port</value></param>
<param><key>label</key><value>dest port</value></param>
<param><key>value</key><value>5003</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>p</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>ipaddr</key><value>udp_host</value></param>
<param><key>port</key><value>udp_port</value></param>
<param><key>psize</key><value>2*240</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>240</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
