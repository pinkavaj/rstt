<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rstt_decode</value></param>
<param><key>title</key><value>RSTT Decode</value></param>
<param><key>description</key><value>Decode telemetry from Vaisala weather sonde RS-92, expect demodulated (GMSK 4800baud) at input.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>RSTT</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>rstt_symbols2bites</key>
<param><key>id</key><value>rstt_symbols2bites_0</value></param>
<param><key>sync_nbites</key><value>20*10</value></param>
</block>
<block>
<key>rstt_bites2bytes</key>
<param><key>id</key><value>rstt_bites2bytes_0</value></param>
<param><key>sync_nbytes</key><value>32</value></param>
</block>
<block>
<key>rstt_bytes2frames</key>
<param><key>id</key><value>rstt_bytes2frames_0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>240</value></param>
</block>
<connection><source_block_id>rstt_symbols2bites_0</source_block_id><sink_block_id>rstt_bites2bytes_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rstt_bites2bytes_0</source_block_id><sink_block_id>rstt_bytes2frames_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rstt_bytes2frames_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>rstt_symbols2bites_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
